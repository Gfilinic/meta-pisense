
# Modify DEFAULTBACKEND
DEFAULTBACKEND = "drm"

PACKAGECONFIG:remove = "xwayland"

